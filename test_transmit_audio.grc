options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: test_vco_audio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: time
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: samp_rate
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*10
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*math.pi
  states: {state: disabled}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*math.pi*1e3
  states: {}
- name: blocks_vco_f_1
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*math.pi
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: info_with_audio_mod_source_str2samp_0_0
  id: info_with_audio_mod_source_str2samp
  parameters:
    fs: samp_rate
    msg: hello
    t: time
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"FFT of the modulated message"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    color1: green
    name: '"The bits message"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"The message modulated with 2 freqs"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_1, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_throttle2_1, '0', blocks_vco_c_0, '0']
- [blocks_throttle2_1, '0', blocks_vco_f_0, '0']
- [blocks_vco_c_0, '0', audio_sink_1, '0']
- [blocks_vco_c_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_vco_c_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_vco_f_0, '0', audio_sink_0, '0']
- [blocks_vco_f_0, '0', audio_sink_1, '0']
- [blocks_vco_f_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_vco_f_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [info_with_audio_mod_source_str2samp_0_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2

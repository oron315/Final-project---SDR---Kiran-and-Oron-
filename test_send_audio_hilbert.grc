options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: test_send_audio_hilbert
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: SNR_lin
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: int(16e3)
  states: {}
- name: sig_amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: analog_fm_demod_cf_1
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '6000'
    chan_rate: samp_rate
    deviation: 1e3
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: sig_amp/SNR_lin
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: sig_amp/SNR_lin
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_noise_source_x_0_1
  id: analog_noise_source_x
  parameters:
    amp: sig_amp/SNR_lin
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-2'
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_1_0
  id: blocks_add_const_vxx
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_1_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-2e3'
    sample_rate: samp_rate
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*10
    type: float
  states: {state: disabled}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: sig_amp
    samp_rate: samp_rate
    sensitivity: 2*math.pi*1e3
  states: {state: disabled}
- name: blocks_vco_c_0_0
  id: blocks_vco_c
  parameters:
    amplitude: sig_amp
    samp_rate: samp_rate
    sensitivity: 2*math.pi*1e3
  states: {state: disabled}
- name: blocks_vco_c_0_1
  id: blocks_vco_c
  parameters:
    amplitude: sig_amp
    samp_rate: samp_rate
    sensitivity: 2*math.pi*1e3
  states: {state: disabled}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*math.pi*1e3
  states: {state: disabled}
- name: blocks_vco_f_0_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*math.pi*1e3
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {state: disabled}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '6500'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: info_with_audio_demod_samp2str_1
  id: info_with_audio_demod_samp2str
  parameters:
    fs: samp_rate
    t: time
    timeout: '3'
    voltage: '1'
  states: {}
- name: info_with_audio_mod_source_str2samp_0_0
  id: info_with_audio_mod_source_str2samp
  parameters:
    fs: samp_rate
    msg: hello
    t: time
  states: {state: disabled}
- name: info_with_audio_mod_source_str2samp_0_0_0
  id: info_with_audio_mod_source_str2samp
  parameters:
    fs: samp_rate
    msg: hello
    t: time
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"FFT of the modulated message"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"FFT of the DEmodulated message"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    color1: green
    marker1: '0'
    name: '"The bits message"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"The message modulated with 2 freqs"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2_1
  id: qtgui_time_sink_x
  parameters:
    color1: green
    marker1: '0'
    name: '"The bits message"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_0_2_2
  id: qtgui_time_sink_x
  parameters:
    color1: green
    name: '"The bits message after FM mod and demod"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}

connections:
- [analog_fm_demod_cf_1, '0', blocks_add_const_vxx_1, '0']
- [analog_fm_demod_cf_1, '0', info_with_audio_demod_samp2str_1, '0']
- [analog_fm_demod_cf_1, '0', qtgui_freq_sink_x_0_1_0, '0']
- [analog_fm_demod_cf_1, '0', qtgui_time_sink_x_0_2_2, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '1']
- [analog_noise_source_x_0_1, '0', blocks_add_xx_1_0, '1']
- [audio_source_0, '0', hilbert_fc_0, '0']
- [blocks_add_const_vxx_1, '0', info_with_audio_demod_samp2str_1, '0']
- [blocks_add_const_vxx_1, '0', qtgui_freq_sink_x_0_1_0, '0']
- [blocks_add_const_vxx_1, '0', qtgui_time_sink_x_0_2_2, '0']
- [blocks_add_const_vxx_1_0, '0', blocks_throttle2_1, '0']
- [blocks_add_const_vxx_1_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_add_const_vxx_1_0_0, '0', blocks_throttle2_1_0, '0']
- [blocks_add_const_vxx_1_0_0, '0', qtgui_time_sink_x_0_2_1, '0']
- [blocks_add_xx_1, '0', analog_fm_demod_cf_1, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_add_xx_1, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_add_xx_1_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_add_xx_1_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_1_0, '0', blocks_vco_c_0_0, '0']
- [blocks_throttle2_1_0, '0', blocks_vco_f_0_0, '0']
- [blocks_vco_f_0, '0', blocks_throttle2_1, '0']
- [blocks_vco_f_0_0, '0', hilbert_fc_0, '0']
- [blocks_vco_f_0_0, '0', low_pass_filter_0_0, '0']
- [hilbert_fc_0, '0', analog_fm_demod_cf_1, '0']
- [hilbert_fc_0, '0', qtgui_freq_sink_x_0_1, '0']
- [hilbert_fc_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [hilbert_fc_1, '0', blocks_add_xx_1_0, '0']
- [hilbert_fc_1, '0', qtgui_freq_sink_x_0_1, '0']
- [info_with_audio_mod_source_str2samp_0_0, '0', blocks_add_const_vxx_1_0, '0']
- [info_with_audio_mod_source_str2samp_0_0, '0', blocks_vco_f_0, '0']
- [info_with_audio_mod_source_str2samp_0_0_0, '0', blocks_add_const_vxx_1_0_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_1, '0']
- [low_pass_filter_0_0, '0', hilbert_fc_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2

options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: test_demod_info
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: time
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters: {}
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    fh: '-1.0'
    max_dev: 75e3
    tau: '75e-6'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*10
    type: float
  states: {}
- name: info_with_audio_demod_samp2str_0
  id: info_with_audio_demod_samp2str
  parameters:
    fs: samp_rate
    t: time
    timeout: '3'
    voltage: '1'
  states: {}
- name: info_with_audio_mod_source_str2samp_0
  id: info_with_audio_mod_source_str2samp
  parameters:
    fs: samp_rate
    msg: hello
    t: time
  states: {}

connections:
- [blocks_throttle2_0, '0', info_with_audio_demod_samp2str_0, '0']
- [info_with_audio_mod_source_str2samp_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2

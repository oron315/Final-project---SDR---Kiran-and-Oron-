options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: test_recieve_audio
    output_language: python
    title: test_recieve_audio
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: int(16e3)
  states: {}
- name: time
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: analog_fm_demod_cf_1_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '3000'
    audio_stop: '4000'
    chan_rate: samp_rate
    deviation: 1e3
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-85'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: int(16e3)
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-2e3'
    sample_rate: samp_rate
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '6500'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: info_with_audio_demod_samp2str_0
  id: info_with_audio_demod_samp2str
  parameters:
    fs: samp_rate
    t: '1'
    timeout: '3'
    voltage: '1'
  states: {state: disabled}
- name: info_with_audio_demod_samp2str_1
  id: info_with_audio_demod_samp2str
  parameters:
    fs: samp_rate
    t: time
    timeout: '3'
    voltage: '1'
  states: {state: disabled}
- name: info_with_audio_demod_samp2str_2
  id: info_with_audio_demod_samp2str
  parameters:
    fs: samp_rate
    t: time
    timeout: '3'
    voltage: '1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 4e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.1e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 4e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"FFT of the DEmodulated message"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"FFT of the DEmodulated message"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"The message modulated with 2 freqs"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_2
  id: qtgui_time_sink_x
  parameters:
    color1: green
    name: '"The bits message after FM"'
    size: '10240'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '5'
    ymin: '-5'
  states: {}

connections:
- [analog_fm_demod_cf_1_0, '0', info_with_audio_demod_samp2str_2, '0']
- [analog_fm_demod_cf_1_0, '0', qtgui_time_sink_x_0_2_2, '0']
- [analog_simple_squelch_cc_0, '0', blocks_freqshift_cc_0, '0']
- [audio_source_0, '0', hilbert_fc_1, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0_0, '0']
- [blocks_throttle2_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_1_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [hilbert_fc_1, '0', blocks_throttle2_0, '0']
- [hilbert_fc_1, '0', low_pass_filter_1, '0']
- [low_pass_filter_0_0, '0', analog_fm_demod_cf_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2

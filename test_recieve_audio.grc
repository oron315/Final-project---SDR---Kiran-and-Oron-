options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: test_tranfer_audio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: time
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_fm_demod_cf_1
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate
    deviation: 1e3
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-2'
    type: float
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '6500'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: info_with_audio_demod_samp2str_1
  id: info_with_audio_demod_samp2str
  parameters:
    fs: samp_rate
    t: time
    timeout: '3'
    voltage: '1'
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"FFT of the DEmodulated message"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"The message modulated with 2 freqs"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2_2
  id: qtgui_time_sink_x
  parameters:
    color1: green
    name: '"The bits message after FM"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}

connections:
- [analog_fm_demod_cf_1, '0', blocks_add_const_vxx_1, '0']
- [audio_source_0, '0', hilbert_fc_1, '0']
- [blocks_add_const_vxx_1, '0', info_with_audio_demod_samp2str_1, '0']
- [blocks_add_const_vxx_1, '0', qtgui_freq_sink_x_0_1_0, '0']
- [blocks_add_const_vxx_1, '0', qtgui_time_sink_x_0_2_2, '0']
- [hilbert_fc_1, '0', analog_fm_demod_cf_1, '0']
- [hilbert_fc_1, '0', qtgui_time_sink_x_0_2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
